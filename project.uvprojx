# Keil uVision project project.uvprojx, settings and files
target rtthread-m55m1 (6220000::V6.22::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\nu_packages\TPC;packages\LVGL-v9.4.0\src\libs\gltf\gltf_view\assets;packages\LVGL-v9.4.0\src\draw\espressif\ppa;packages\LVGL-v9.4.0\src\widgets\buttonmatrix;rt-thread\components\drivers\spi;packages\LVGL-v9.4.0\src\widgets\tileview;packages\LVGL-v9.4.0\src\widgets\spinner;packages\ml-embedded-evaluation-kit\dependencies\cmsis-dsp;packages\LVGL-v9.4.0\src\draw\nema_gfx;packages\LVGL-v9.4.0\src\drivers\display\st7735;packages\LVGL-v9.4.0\src\libs\svg;rt-thread\components\net\sal\include\socket;rt-thread\components\net\lwip\lwip-2.1.2\src\include;packages\ml-embedded-evaluation-kit\source\application\main\include;libraries\m5531\StdDriver\inc;rt-thread\components\libc\posix\io\stdio;libraries\nu_packages\LT7381;packages\LVGL-v9.4.0\src\libs\expat;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\ml-embedded-evaluation-kit\source\profiler\include;packages\LVGL-v9.4.0\src\libs\tjpgd;packages\LVGL-v9.4.0\src\layouts\grid;rt-thread\components\net\sal\include\dfs_net;packages\LVGL-v9.4.0\src\drivers\qnx;packages\ramdisk-latest\inc;packages\LVGL-v9.4.0\src\widgets\checkbox;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423_ECO;packages\LVGL-v9.4.0\env_support\rt-thread\squareline;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\lv_vg_lite_hal;packages\LVGL-v9.4.0\src\drivers\opengles\glad\include\EGL;packages\LVGL-v9.4.0\src\libs\barcode;packages\LVGL-v9.4.0\src\draw\nxp\pxp;packages\LVGL-v9.4.0\src\osal;rt-thread\components\legacy;packages\LVGL-v9.4.0\src\libs\fsdrv;packages\LVGL-v9.4.0\src\draw\sw\arm2d;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLiteKernel;rt-thread\components\libc\compilers\common\include;packages\LVGL-v9.4.0\src\others\monkey;packages\LVGL-v9.4.0\src\drivers\display\drm;packages\ml-embedded-evaluation-kit\source\hal\source\components\poster\include;packages\netutils-latest\ntp;rt-thread\components\utilities\ulog;packages\LVGL-v9.4.0\src\widgets\scale;rt-thread\components\drivers\sensors;packages\LVGL-v9.4.0\src\libs\frogfs\src;rt-thread\components\net\sal\include;packages\LVGL-v9.4.0\src\drivers\display\lcd;packages\LVGL-v9.4.0\src\libs\lz4;applications;packages\LVGL-v9.4.0\src\drivers\display\nv3007;packages\LVGL-v9.4.0\src\libs\bin_decoder;packages\LVGL-v9.4.0\src\widgets\arc;packages\LVGL-v9.4.0\src\widgets\span;packages\ml-embedded-evaluation-kit\dependencies\core-driver\include;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1216;packages\ml-embedded-evaluation-kit\source\application\api\use_case\object_detection\include;packages\ml-embedded-evaluation-kit\source\hal\source\components\memheap_helper\include;packages\ml-embedded-evaluation-kit\source\math\include;packages\LVGL-v9.4.0\src\core;packages\LVGL-v9.4.0\src\libs\gif;packages\LVGL-v9.4.0\src\drivers\display\ft81x;rt-thread\components\libc\posix\ipc;packages\LVGL-v9.4.0\src\draw\sw\blend\helium;packages\LVGL-v9.4.0\src\draw\opengles;rt-thread\components\libc\posix\delay;packages\LVGL-v9.4.0\src\draw\eve;packages\LVGL-v9.4.0\src\others\translation;packages\ml-embedded-evaluation-kit\dependencies\RyanMqtt\common;packages\ml-embedded-evaluation-kit\dependencies\tensorflow\tensorflow\lite\micro\tools\make\downloads\ruy;libraries\m5531\StdDriver\inc\gdma;rt-thread\components\drivers\include;packages\LVGL-v9.4.0\src\libs\tiny_ttf;rt-thread\components\drivers\include;rt-thread\components\net\netdev\include;packages\LVGL-v9.4.0\src\drivers\wayland;packages\LVGL-v9.4.0\src\libs\bmp;libraries\m5531\StdDriver\src;packages\LVGL-v9.4.0\src\others\snapshot;packages\LVGL-v9.4.0\src\themes\simple;packages\LVGL-v9.4.0\src\widgets\objx_templ;packages\LVGL-v9.4.0\src\others\observer;packages\LVGL-v9.4.0\src\drivers\x11;packages\ml-embedded-evaluation-kit\dependencies\cmsis-dsp\Include;packages\LVGL-v9.4.0\src\widgets\property;libraries\nu_packages\AudioCodec;packages\LVGL-v9.4.0\src\libs\lodepng;rt-thread\components\net\sal\include\socket\sys_socket;packages\LVGL-v9.4.0\env_support\rt-thread;packages\LVGL-v9.4.0\src\draw\convert;packages\LVGL-v9.4.0\src\misc;packages\ml-embedded-evaluation-kit\source\hal\source\components\camera\include;packages\LVGL-v9.4.0\src\libs\thorvg\rapidjson;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\libc\compilers\common\extension;rt-thread\components\net\sal\impl;packages\ml-embedded-evaluation-kit\source\log\include;rt-thread\components\net\lwip\port;packages\LVGL-v9.4.0\src\libs\thorvg\rapidjson\internal;packages\ml-embedded-evaluation-kit\dependencies\TinyJPEG;packages\LVGL-v9.4.0\src\widgets\imagebutton;packages\LVGL-v9.4.0\src\libs\libpng;packages\ml-embedded-evaluation-kit\source\hal\source\components\audio\include;packages\LVGL-v9.4.0\src\drivers\display\tft_espi;packages\LVGL-v9.4.0\src\libs\rlottie;rt-thread\components\dfs\include;packages\LVGL-v9.4.0\env_support\rt-thread\squareline\ui\lvgl;packages\LVGL-v9.4.0\src\others\font_manager;rt-thread\components\fal\inc;packages\ml-embedded-evaluation-kit\source\hal\source\components\platform_pmu\include;packages\LVGL-v9.4.0\src\themes;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\inc;packages\LVGL-v9.4.0\src\draw\sw\blend;packages\LVGL-v9.4.0\src\layouts;rt-thread\components\drivers\include;.;board;packages\LVGL-v9.4.0\src\indev;rt-thread\components\drivers\include;packages\ml-embedded-evaluation-kit\source\hal\source\platform\rtthread\include;packages\LVGL-v9.4.0\src\widgets\textarea;packages\LVGL-v9.4.0\src\widgets\list;packages\LVGL-v9.4.0\src\draw;packages\LVGL-v9.4.0\src\libs\rle;packages\ml-embedded-evaluation-kit\dependencies\RyanMqtt\platform\rtthread;rt-thread\components\libc\cplusplus;packages\LVGL-v9.4.0\src\misc\cache\instance;packages\LVGL-v9.4.0\src\widgets\canvas;packages\ml-embedded-evaluation-kit\source\hal\source\components\uvc\include;packages\LVGL-v9.4.0\src\libs\freetype;packages\LVGL-v9.4.0\src\draw\convert\helium;libraries\m5531\StdDriver\src\scu;packages\mpu6xxx-latest\inc;packages\LVGL-v9.4.0\src\draw\sw;packages\LVGL-v9.4.0\src\libs\gstreamer;packages\LVGL-v9.4.0\src\libs\gltf\gltf_view;packages\LVGL-v9.4.0\src\draw\dma2d;libraries\m5531\rtt_port;rt-thread\components\libc\posix\io\poll;packages\LVGL-v9.4.0\src\others\imgfont;rt-thread\components\drivers\include;packages\LVGL-v9.4.0\src\stdlib;packages\LVGL-v9.4.0\src\drivers\draw\eve;packages\LVGL-v9.4.0\src\themes\default;packages\LVGL-v9.4.0\src\themes\mono;packages\LVGL-v9.4.0\src\others\sysmon;packages\LVGL-v9.4.0\src\widgets\spinbox;rt-thread\components\finsh;packages\LVGL-v9.4.0\src\drivers\display\st7789;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;packages\ml-embedded-evaluation-kit\dependencies\tensorflow\tensorflow\lite\micro\tools\make\downloads\gemmlowp;packages\LVGL-v9.4.0\src;packages\ml-embedded-evaluation-kit\source\hal\source\components\stdout\include;packages\LVGL-v9.4.0\src\drivers\opengles\glad\include\glad;rt-thread\components\drivers\include;packages\LVGL-v9.4.0\src\widgets\tabview;packages\ml-embedded-evaluation-kit\dependencies\tensorflow\tensorflow\lite\micro\tools\make\downloads\kissfft;packages\LVGL-v9.4.0\src\libs\ffmpeg;rt-thread\libcpu\arm\cortex-m55;packages\LVGL-v9.4.0\src\widgets\arclabel;packages\LVGL-v9.4.0\src\others\xml\parsers;packages\LVGL-v9.4.0\src\widgets\calendar;packages\ml-embedded-evaluation-kit\dependencies\RyanMqtt\mqttclient;packages\LVGL-v9.4.0\src\libs\gltf\gltf_view\ibl;packages\LVGL-v9.4.0\src\libs\FT800-FT813;packages\LVGL-v9.4.0\src\widgets\3dtexture;rt-thread\components\drivers\include;packages\LVGL-v9.4.0\src\libs\gif\AnimatedGIF\src;packages\ml-embedded-evaluation-kit\source\hal\include;packages\LVGL-v9.4.0\src\widgets\table;packages\LVGL-v9.4.0\src\widgets\chart;libraries\m5531\StdDriver;packages\LVGL-v9.4.0\src\libs\frogfs\include\frogfs;packages\LVGL-v9.4.0\src\drivers\nuttx;packages\LVGL-v9.4.0\src\others\gridnav;packages\LVGL-v9.4.0\src\widgets\image;libraries\nu_packages\LV_PORT;packages\LVGL-v9.4.0\src\others\file_explorer;libraries\nu_packages\NuUtils\inc;packages\LVGL-v9.4.0\src\drivers\opengles\assets;packages\LVGL-v9.4.0\src\drivers\opengles;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLite\Series\gc255\0x40A;packages\LVGL-v9.4.0\src\drivers\sdl;packages\LVGL-v9.4.0\src\misc\cache\class;packages\LVGL-v9.4.0\src\widgets\led;packages\LVGL-v9.4.0\src\others\xml;packages\LVGL-v9.4.0\src\widgets\msgbox;packages\LVGL-v9.4.0\src\widgets\menu;packages\LVGL-v9.4.0\src\widgets\line;packages\ml-embedded-evaluation-kit\dependencies\cmsis-nn;packages\LVGL-v9.4.0\src\others\vg_lite_tvg;packages\LVGL-v9.4.0\src\draw\sw\blend\neon;packages\LVGL-v9.4.0\src\drivers\evdev;packages\LVGL-v9.4.0\src\widgets\animimage;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423;packages\LVGL-v9.4.0\src\drivers\display\ili9341;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1215;packages\LVGL-v9.4.0\src\draw\renesas\dave2d;packages\LVGL-v9.4.0\src\libs\gltf\fastgltf;libraries\m5531\StdDriver\src\gdma;packages\LVGL-v9.4.0\src\libs\vg_lite_driver\VGLite;packages\ml-embedded-evaluation-kit\dependencies\RyanMqtt\pahoMqtt;packages\LVGL-v9.4.0\src\tick;rt-thread\components\utilities\utest;packages\LVGL-v9.4.0\src\libs\thorvg;packages\LVGL-v9.4.0\src\widgets\keyboard;packages\LVGL-v9.4.0\src\libs\thorvg\rapidjson\error;packages\LVGL-v9.4.0\src\libs\libjpeg_turbo;packages\LVGL-v9.4.0\src\draw\sdl;packages\LVGL-v9.4.0\src\font;packages\ml-embedded-evaluation-kit\source\hal\source\components\ext_file\include;packages\ml-embedded-evaluation-kit\ethos-u55-256-gnu_generated\object_detection\include;packages\LVGL-v9.4.0\src\drivers\display\nxp_elcdif;packages\LVGL-v9.4.0\src\drivers\uefi;packages\LVGL-v9.4.0\src\stdlib\builtin;packages\ml-embedded-evaluation-kit\source\application\api\common\include;packages\LVGL-v9.4.0\src\widgets\lottie;rt-thread\include;packages\LVGL-v9.4.0\src\drivers\display\renesas_glcdc;packages\LVGL-v9.4.0\src\draw\sw\blend\arm2d;rt-thread\components\drivers\include;rt-thread\components\legacy\dfs;packages\LVGL-v9.4.0\src\widgets\win;packages\LVGL-v9.4.0\src\drivers\opengles\opengl_shader;libraries\m5531\Device\Nuvoton\M5531\Include;packages\LVGL-v9.4.0\src\others\test;packages\LVGL-v9.4.0\src\widgets\roller;rt-thread\libcpu\arm\common;packages\LVGL-v9.4.0\src\draw\vg_lite;packages\LVGL-v9.4.0\src\drivers;packages\LVGL-v9.4.0\src\draw\convert\neon;packages\LVGL-v9.4.0\src\libs\gltf\math;packages\LVGL-v9.4.0\src\draw\nxp\g2d;packages\LVGL-v9.4.0\src\libs\gltf\gltf_data;packages\LVGL-v9.4.0\src\drivers\display\fb;packages\ml-embedded-evaluation-kit\source\hal\source\components\npu\include;packages\LVGL-v9.4.0\src\others\fragment;packages\ml-embedded-evaluation-kit\dependencies\tensorflow;libraries\m5531\rtt_port\emac;packages\LVGL-v9.4.0\src\widgets\button;packages\LVGL-v9.4.0\src\display;packages\ml-embedded-evaluation-kit\dependencies\cmsis-dsp\PrivateInclude;packages\LVGL-v9.4.0\src\others\ime;packages\LVGL-v9.4.0\src\widgets\dropdown;packages\LVGL-v9.4.0\src\widgets\bar;packages\LVGL-v9.4.0\src\misc\cache;packages\LVGL-v9.4.0\src\drivers\display\st7796;packages\ml-embedded-evaluation-kit\dependencies\tensorflow\tensorflow\lite\micro\tools\make\downloads\flatbuffers\include;packages\LVGL-v9.4.0\src\drivers\opengles\glad\include\KHR;packages\LVGL-v9.4.0\src\widgets\label;packages\ml-embedded-evaluation-kit\source\use_case\object_detection\include;libraries\nu_packages\CMSIS\Core\Include;rt-thread\components\drivers\audio;packages\ml-embedded-evaluation-kit\source\hal\source\components\lcd\source\rtthread;packages\LVGL-v9.4.0\src\widgets\slider;packages\LVGL-v9.4.0\src\libs\qrcode;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;libraries\nu_packages\CCAP_Sensors;packages\LVGL-v9.4.0\src\libs\gltf\stb_image;packages\LVGL-v9.4.0\src\drivers\libinput;packages\LVGL-v9.4.0\src\layouts\flex;libraries\m5531\StdDriver\inc\scu;packages\LVGL-v9.4.0\env_support\rt-thread\squareline\ui;rt-thread\components\drivers\touch;libraries\m5531\rtt_port\spim;board\NuPinConfig;packages\LVGL-v9.4.0\src\widgets\switch;packages\LVGL-v9.4.0\src\drivers\windows;libraries\nu_packages\LV_PORT\draw_gdma;packages\ml-embedded-evaluation-kit\source\hal\source\components\lcd\include;packages\ml-embedded-evaluation-kit\dependencies\RyanMqtt\example;packages\ml-embedded-evaluation-kit\dependencies\cmsis-nn\Include;packages\LVGL-v9.4.0\src\drivers\display\lovyan_gfx;packages\LVGL-v9.4.0\src\drivers\display\st_ltdc
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\linking_scripts\M55M1.scatter
  group Applications
    applications/: main.c mnt.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPlusPlus
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_Semaphore.cpp cxx_Thread.cpp cxx_crt_init.c cxx_Mutex.cpp
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m55/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    libraries/m5531/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
    libraries/m5531/rtt_port/: cache_ops.c drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_dmic.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gdma.c drv_gpio.c drv_i2c.c drv_i2s.c drv_lpadc.c drv_lpi2c.c drv_lpspi.c drv_lptimer.c drv_lpuart.c drv_memheap.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_sys.c drv_timer.c drv_tpwm.c drv_trng.c drv_ttmr.c drv_uart.c drv_ui2c.c drv_uspi.c drv_uuart.c drv_wdt.c safe_memfun.c
    libraries/m5531/rtt_port/emac/: drv_gmac.c mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
    libraries/m5531/rtt_port/spim/: drv_spim.c hyperram_code.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal.c fal_flash.c fal_rtt.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/m5531/StdDriver/src/gdma/: dma350_address_remap_template.c dma350_ch_drv.c dma350_drv.c dma350_lib.c
    libraries/m5531/StdDriver/src/: nu_acmp.c nu_awf.c nu_bpwm.c nu_canfd.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dmic.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_i3c.c nu_kdf.c nu_ks.c nu_lpadc.c nu_lpgpio.c nu_lpi2c.c nu_lppdma.c nu_lpspi.c nu_lptmr.c nu_lptmr_pwm.c nu_lpuart.c nu_otfc.c nu_pdma.c nu_pmc.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_spim_hyper.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_ttmr.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
    libraries/m5531/StdDriver/src/scu/: nu_dpm.c nu_fvc.c nu_mpc_sie_drv.c
  group LVGL
    packages/LVGL-v9.4.0/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    packages/LVGL-v9.4.0/src/stdlib/builtin/: lv_string_builtin.c lv_sprintf_builtin.c lv_tlsf.c lv_mem_core_builtin.c
    packages/LVGL-v9.4.0/src/draw/vg_lite/: lv_draw_vg_lite_mask_rect.c lv_vg_lite_stroke.c lv_vg_lite_grad.c lv_vg_lite_utils.c lv_draw_vg_lite_line.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_label.c lv_draw_buf_vg_lite.c lv_vg_lite_pending.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_fill.c lv_vg_lite_path.c lv_draw_vg_lite_img.c lv_vg_lite_math.c
    packages/LVGL-v9.4.0/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    packages/LVGL-v9.4.0/src/libs/svg/: lv_svg.c lv_svg_token.c lv_svg_render.c lv_svg_parser.c lv_svg_decoder.c
    packages/LVGL-v9.4.0/src/misc/: lv_style_gen.c lv_tree.c lv_text_ap.c lv_utils.c lv_log.c lv_matrix.c lv_math.c lv_grad.c lv_timer.c lv_circle_buf.c lv_color.c lv_palette.c lv_templ.c lv_text.c lv_event.c lv_lru.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_ll.c lv_array.c lv_bidi.c lv_anim.c lv_async.c lv_area.c lv_anim_timeline.c lv_color_op.c lv_fs.c lv_iter.c lv_profiler_builtin.c
    packages/LVGL-v9.4.0/src/draw/nema_gfx/: lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_stm32_hal.c lv_nema_gfx_path.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_vector.c lv_draw_nema_gfx_arc.c
    packages/LVGL-v9.4.0/src/drivers/libinput/: lv_xkb.c lv_libinput.c
    packages/LVGL-v9.4.0/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-v9.4.0/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_memfs.c lv_fs_cbfs.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_frogfs.c
    packages/LVGL-v9.4.0/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v9.4.0/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-v9.4.0/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    packages/LVGL-v9.4.0/src/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar.c lv_calendar_chinese.c lv_calendar_header_dropdown.c
    packages/LVGL-v9.4.0/src/drivers/display/st7796/: lv_st7796.c
    packages/LVGL-v9.4.0/src/others/xml/: lv_xml_style.c lv_xml_test.c lv_xml_parser.c lv_xml.c lv_xml_base_types.c lv_xml_widget.c lv_xml_utils.c lv_xml_component.c lv_xml_translation.c lv_xml_load.c lv_xml_update.c
    packages/LVGL-v9.4.0/src/draw/nxp/pxp/: lv_draw_pxp_img.c lv_pxp_cfg.c lv_draw_buf_pxp.c lv_draw_pxp_fill.c lv_draw_pxp.c lv_pxp_utils.c lv_draw_pxp_layer.c lv_pxp_osa.c
    packages/LVGL-v9.4.0/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    packages/LVGL-v9.4.0/src/drivers/sdl/: lv_sdl_mousewheel.c lv_sdl_window.c lv_sdl_keyboard.c lv_sdl_mouse.c
    packages/LVGL-v9.4.0/src/draw/opengles/: lv_draw_opengles.c
    packages/LVGL-v9.4.0/src/drivers/nuttx/: lv_nuttx_lcd.c lv_nuttx_mouse.c lv_nuttx_image_cache.c lv_nuttx_libuv.c lv_nuttx_cache.c lv_nuttx_fbdev.c lv_nuttx_profiler.c lv_nuttx_entry.c lv_nuttx_touchscreen.c
    packages/LVGL-v9.4.0/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v9.4.0/src/layouts/grid/: lv_grid.c
    packages/LVGL-v9.4.0/src/draw/renesas/dave2d/: lv_draw_dave2d_border.c lv_draw_dave2d_triangle.c lv_draw_dave2d_arc.c lv_draw_dave2d_utils.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_fill.c lv_draw_dave2d.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c
    packages/LVGL-v9.4.0/src/drivers/uefi/: lv_uefi_indev_keyboard.c lv_uefi_display.c lv_uefi_indev_pointer.c lv_uefi_private.c lv_uefi_indev_touch.c lv_uefi_context.c
    packages/LVGL-v9.4.0/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-v9.4.0/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    packages/LVGL-v9.4.0/src/others/xml/parsers/: lv_xml_button_parser.c lv_xml_roller_parser.c lv_xml_dropdown_parser.c lv_xml_slider_parser.c lv_xml_textarea_parser.c lv_xml_qrcode_parser.c lv_xml_spangroup_parser.c lv_xml_image_parser.c lv_xml_checkbox_parser.c lv_xml_label_parser.c lv_xml_arc_parser.c lv_xml_obj_parser.c lv_xml_scale_parser.c lv_xml_spinbox_parser.c lv_xml_table_parser.c lv_xml_calendar_parser.c lv_xml_keyboard_parser.c lv_xml_bar_parser.c lv_xml_switch_parser.c lv_xml_tabview_parser.c lv_xml_buttonmatrix_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c
    packages/LVGL-v9.4.0/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_20.c lv_font_montserrat_28.c lv_font_fmt_txt.c lv_font_montserrat_16.c lv_binfont_loader.c lv_font.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_18.c lv_font_montserrat_22.c lv_font_montserrat_14.c lv_font_montserrat_36.c lv_font_montserrat_24.c lv_font_unscii_8.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_unscii_16.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_40.c lv_font_montserrat_34.c lv_font_montserrat_14_aligned.c lv_font_montserrat_44.c lv_font_montserrat_8.c lv_font_montserrat_38.c lv_font_source_han_sans_sc_16_cjk.c lv_font_montserrat_48.c lv_font_montserrat_46.c lv_font_source_han_sans_sc_14_cjk.c lv_font_montserrat_42.c
    packages/LVGL-v9.4.0/src/widgets/lottie/: lv_lottie.c
    packages/LVGL-v9.4.0/src/drivers/opengles/opengl_shader/: lv_opengl_shader_program.c lv_opengl_shader_manager.c
    packages/LVGL-v9.4.0/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v9.4.0/src/draw/: lv_image_decoder.c lv_draw_triangle.c lv_draw_rect.c lv_draw_vector.c lv_draw.c lv_draw_mask.c lv_draw_3d.c lv_draw_buf.c lv_draw_image.c lv_draw_arc.c lv_draw_label.c lv_draw_line.c
    packages/LVGL-v9.4.0/src/draw/sw/blend/: lv_draw_sw_blend_to_l8.c lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c
    packages/LVGL-v9.4.0/src/widgets/menu/: lv_menu.c
    packages/LVGL-v9.4.0/src/drivers/wayland/: lv_wl_window.c lv_wl_dmabuf.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_touch.c lv_wayland.c lv_wayland_smm.c lv_wl_keyboard.c lv_wl_cache.c lv_wl_shm.c lv_wl_pointer.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    packages/LVGL-v9.4.0/src/libs/expat/: xmltok_impl.c xmlparse.c xmlrole.c xmltok.c xmltok_ns.c
    packages/LVGL-v9.4.0/src/libs/vg_lite_driver/VGLite/: vg_lite_image.c vg_lite_path.c vg_lite_matrix.c vg_lite.c vg_lite_stroke.c
    packages/LVGL-v9.4.0/src/libs/lodepng/: lodepng.c lv_lodepng.c
    packages/LVGL-v9.4.0/src/widgets/chart/: lv_chart.c
    packages/LVGL-v9.4.0/src/libs/freetype/: lv_freetype_image.c lv_freetype_glyph.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    packages/LVGL-v9.4.0/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v9.4.0/src/draw/nxp/g2d/: lv_draw_g2d.c lv_g2d_utils.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_draw_g2d_fill.c lv_draw_buf_g2d.c
    packages/LVGL-v9.4.0/src/osal/: lv_cmsis_rtos2.c lv_windows.c lv_os.c lv_mqx.c lv_sdl2.c lv_freertos.c lv_pthread.c lv_rtthread.c lv_linux.c lv_os_none.c
    packages/LVGL-v9.4.0/src/misc/cache/class/: lv_cache_lru_rb.c lv_cache_lru_ll.c lv_cache_sc_da.c
    packages/LVGL-v9.4.0/src/libs/gif/AnimatedGIF/src/: gif.c
    packages/LVGL-v9.4.0/src/draw/eve/: lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_eve.c lv_draw_eve_fill.c lv_draw_eve_triangle.c lv_draw_eve_arc.c lv_draw_eve_ram_g.c lv_draw_eve.c
    packages/LVGL-v9.4.0/src/drivers/evdev/: lv_evdev.c
    packages/LVGL-v9.4.0/src/widgets/label/: lv_label.c
    packages/LVGL-v9.4.0/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-v9.4.0/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    packages/LVGL-v9.4.0/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    packages/LVGL-v9.4.0/src/drivers/opengles/: lv_opengles_glfw.c lv_opengles_debug.c lv_opengles_egl.c lv_opengles_driver.c lv_opengles_texture.c
    packages/LVGL-v9.4.0/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    packages/LVGL-v9.4.0/src/draw/espressif/ppa/: lv_draw_ppa_buf.c lv_draw_ppa_img.c lv_draw_ppa.c lv_draw_ppa_fill.c
    packages/LVGL-v9.4.0/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    packages/LVGL-v9.4.0/src/widgets/table/: lv_table.c
    packages/LVGL-v9.4.0/src/widgets/property/: lv_dropdown_properties.c lv_keyboard_properties.c lv_roller_properties.c lv_textarea_properties.c lv_slider_properties.c lv_image_properties.c lv_animimage_properties.c lv_label_properties.c lv_style_properties.c lv_obj_properties.c
    packages/LVGL-v9.4.0/src/drivers/windows/: lv_windows_display.c lv_windows_input.c lv_windows_context.c
    packages/LVGL-v9.4.0/src/core/: lv_group.c lv_obj_pos.c lv_obj_draw.c lv_obj_property.c lv_obj_style.c lv_obj_scroll.c lv_refr.c lv_obj_class.c lv_obj.c lv_obj_tree.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_style_gen.c
    packages/LVGL-v9.4.0/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-v9.4.0/src/drivers/display/drm/: lv_linux_drm_egl.c lv_linux_drm_common.c lv_linux_drm.c
    packages/LVGL-v9.4.0/src/misc/cache/: lv_cache.c lv_cache_entry.c
    packages/LVGL-v9.4.0/src/stdlib/rtthread/: lv_string_rtthread.c lv_sprintf_rtthread.c lv_mem_core_rtthread.c
    packages/LVGL-v9.4.0/src/widgets/roller/: lv_roller.c
    packages/LVGL-v9.4.0/src/drivers/opengles/glad/src/: egl.c gles2.c
    packages/LVGL-v9.4.0/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    packages/LVGL-v9.4.0/src/widgets/animimage/: lv_animimage.c
    packages/LVGL-v9.4.0/src/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v9.4.0/src/drivers/display/st7789/: lv_st7789.c
    packages/LVGL-v9.4.0/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-v9.4.0/src/libs/barcode/: code128.c lv_barcode.c
    packages/LVGL-v9.4.0/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    packages/LVGL-v9.4.0/src/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v9.4.0/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    packages/LVGL-v9.4.0/src/others/monkey/: lv_monkey.c
    packages/LVGL-v9.4.0/src/widgets/led/: lv_led.c
    packages/LVGL-v9.4.0/src/draw/sw/: lv_draw_sw_utils.c lv_draw_sw_line.c lv_draw_sw_box_shadow.c lv_draw_sw_img.c lv_draw_sw_border.c lv_draw_sw_fill.c lv_draw_sw_transform.c lv_draw_sw_grad.c lv_draw_sw_letter.c lv_draw_sw_vector.c lv_draw_sw_mask_rect.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_triangle.c lv_draw_sw_mask.c
    packages/LVGL-v9.4.0/src/widgets/span/: lv_span.c
    packages/LVGL-v9.4.0/src/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v9.4.0/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-v9.4.0/src/: lv_init.c
    packages/LVGL-v9.4.0/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    packages/LVGL-v9.4.0/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-v9.4.0/src/libs/bmp/: lv_bmp.c
    packages/LVGL-v9.4.0/src/display/: lv_display.c
    packages/LVGL-v9.4.0/src/libs/rle/: lv_rle.c
    packages/LVGL-v9.4.0/src/widgets/arc/: lv_arc.c
    packages/LVGL-v9.4.0/src/draw/sw/blend/helium/: lv_blend_helium.S
    packages/LVGL-v9.4.0/src/drivers/display/st7735/: lv_st7735.c
    packages/LVGL-v9.4.0/src/others/gridnav/: lv_gridnav.c
    packages/LVGL-v9.4.0/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    packages/LVGL-v9.4.0/src/stdlib/uefi/: lv_mem_core_uefi.c
    packages/LVGL-v9.4.0/src/widgets/win/: lv_win.c
    packages/LVGL-v9.4.0/src/libs/libpng/: lv_libpng.c
    packages/LVGL-v9.4.0/src/indev/: lv_indev_gesture.c lv_indev_scroll.c lv_indev.c
    packages/LVGL-v9.4.0/src/widgets/3dtexture/: lv_3dtexture.c
    packages/LVGL-v9.4.0/src/drivers/display/ft81x/: lv_ft81x.c
    packages/LVGL-v9.4.0/src/libs/bin_decoder/: lv_bin_decoder.c
    packages/LVGL-v9.4.0/src/others/imgfont/: lv_imgfont.c
    packages/LVGL-v9.4.0/src/libs/tjpgd/: tjpgd.c lv_tjpgd.c
    packages/LVGL-v9.4.0/src/layouts/: lv_layout.c
    packages/LVGL-v9.4.0/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    packages/LVGL-v9.4.0/src/widgets/line/: lv_line.c
    packages/LVGL-v9.4.0/src/widgets/slider/: lv_slider.c
    packages/LVGL-v9.4.0/src/draw/sdl/: lv_draw_sdl.c
    packages/LVGL-v9.4.0/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    packages/LVGL-v9.4.0/src/stdlib/micropython/: lv_mem_core_micropython.c
    packages/LVGL-v9.4.0/src/others/observer/: lv_observer.c
    packages/LVGL-v9.4.0/src/drivers/display/ili9341/: lv_ili9341.c
    packages/LVGL-v9.4.0/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-v9.4.0/src/widgets/bar/: lv_bar.c
    packages/LVGL-v9.4.0/src/drivers/draw/eve/: lv_draw_eve_display.c
    packages/LVGL-v9.4.0/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    packages/LVGL-v9.4.0/src/drivers/display/fb/: lv_linux_fbdev.c
    packages/LVGL-v9.4.0/src/tick/: lv_tick.c
    packages/LVGL-v9.4.0/src/libs/gif/: lv_gif.c
    packages/LVGL-v9.4.0/src/libs/lz4/: lz4.c
    packages/LVGL-v9.4.0/src/themes/: lv_theme.c
    packages/LVGL-v9.4.0/src/drivers/qnx/: lv_qnx.c
    packages/LVGL-v9.4.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-v9.4.0/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb888.c lv_draw_sw_blend_neon_to_rgb565.c
    packages/LVGL-v9.4.0/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    packages/LVGL-v9.4.0/src/widgets/scale/: lv_scale.c
    packages/LVGL-v9.4.0/src/widgets/image/: lv_image.c
    packages/LVGL-v9.4.0/src/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v9.4.0/src/draw/convert/: lv_draw_buf_convert.c
    packages/LVGL-v9.4.0/src/widgets/switch/: lv_switch.c
    packages/LVGL-v9.4.0/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-v9.4.0/src/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v9.4.0/src/drivers/opengles/assets/: lv_opengles_shader.c
    packages/LVGL-v9.4.0/src/others/translation/: lv_translation.c
    packages/LVGL-v9.4.0/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-v9.4.0/src/drivers/display/nv3007/: lv_nv3007.c
    packages/LVGL-v9.4.0/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-v9.4.0/src/widgets/list/: lv_list.c
    packages/LVGL-v9.4.0/src/others/sysmon/: lv_sysmon.c
    packages/LVGL-v9.4.0/src/themes/default/: lv_theme_default.c
    packages/LVGL-v9.4.0/src/libs/gstreamer/: lv_gstreamer.c
    packages/LVGL-v9.4.0/src/others/test/: lv_test_indev.c lv_test_screenshot_compare.c lv_test_helpers.c lv_test_display.c lv_test_indev_gesture.c
    packages/LVGL-v9.4.0/src/stdlib/: lv_mem.c
    packages/LVGL-v9.4.0/src/widgets/arclabel/: lv_arclabel.c
    packages/LVGL-v9.4.0/src/others/vg_lite_tvg/: vg_lite_matrix.c
    packages/LVGL-v9.4.0/src/layouts/flex/: lv_flex.c
    packages/LVGL-v9.4.0/src/widgets/button/: lv_button.c
    packages/LVGL-v9.4.0/src/others/snapshot/: lv_snapshot.c
  group LVGL-port
    packages/LVGL-v9.4.0/env_support/rt-thread/: lv_rt_thread_port.c
    libraries/nu_packages/LV_PORT/draw_gdma/: lv_draw_gdma.c lv_draw_gdma_fill.c lv_draw_gdma_image.c lv_draw_gdma_layer.c
    libraries/nu_packages/LV_PORT/: lv_demo.c lv_port_disp.c lv_port_indev.c
  group LVGL-SquareLine
    packages/LVGL-v9.4.0/env_support/rt-thread/squareline/ui/components/: ui_comp_hook.c
    packages/LVGL-v9.4.0/env_support/rt-thread/squareline/ui/screens/: ui_Screen1.c
    packages/LVGL-v9.4.0/env_support/rt-thread/squareline/ui/: ui.c ui_events.c ui_helpers.c
    packages/LVGL-v9.4.0/env_support/rt-thread/squareline/: lv_ui_entry.c
    packages/LVGL-v9.4.0/env_support/rt-thread/squareline/ui/images/: ui_img_sls_png.c ui_img_m55m1_png.c ui_img_lvgl_png.c ui_img_opennuvoton_logo_png.c ui_img_rtt_png.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/lwiperf/: lwiperf.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/snmp/: snmpv3_mbedtls.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group mlevk_cmsis_dsp
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/TransformFunctions/: arm_mfcc_q15.c arm_cfft_radix4_init_q15.c arm_mfcc_init_f32.c arm_mfcc_f16.c arm_cfft_init_f16.c arm_rfft_q15.c arm_rfft_init_f32.c arm_rfft_q31.c arm_dct4_init_q15.c arm_rfft_fast_init_f64.c arm_rfft_init_q15.c arm_mfcc_init_q15.c arm_cfft_radix2_q15.c arm_cfft_radix4_f16.c arm_cfft_init_q31.c arm_cfft_radix2_init_f32.c arm_bitreversal2.c arm_dct4_init_q31.c arm_cfft_radix4_init_f16.c arm_bitreversal.c arm_dct4_f32.c arm_cfft_init_q15.c arm_cfft_radix2_init_f16.c arm_rfft_fast_f32.c arm_cfft_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_mfcc_init_q31.c arm_cfft_radix2_init_q15.c arm_cfft_radix4_q15.c arm_bitreversal_f16.c arm_rfft_init_q31.c arm_mfcc_f32.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f16.c arm_dct4_q15.c arm_cfft_radix2_f32.c arm_cfft_radix2_f16.c arm_cfft_radix2_init_q31.c arm_cfft_q31.c arm_cfft_init_f64.c arm_rfft_fast_f16.c arm_rfft_f32.c arm_cfft_radix8_f32.c arm_cfft_radix2_q31.c arm_mfcc_init_f16.c arm_cfft_f64.c arm_mfcc_q31.c arm_cfft_q15.c arm_dct4_init_f32.c arm_cfft_f32.c arm_dct4_q31.c arm_cfft_radix4_init_q31.c arm_rfft_fast_f64.c arm_cfft_radix4_q31.c arm_cfft_init_f32.c arm_cfft_radix8_f16.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/StatisticsFunctions/: arm_mse_q31.c arm_logsumexp_dot_prod_f16.c arm_absmin_no_idx_q31.c arm_mse_f16.c arm_absmin_q7.c arm_absmax_q31.c arm_absmax_no_idx_q15.c arm_kullback_leibler_f64.c arm_max_no_idx_q7.c arm_absmax_no_idx_q7.c arm_accumulate_f32.c arm_mean_q7.c arm_power_q15.c arm_max_f64.c arm_min_no_idx_q15.c arm_mse_q7.c arm_rms_f32.c arm_power_f32.c arm_mean_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_f16.c arm_var_f16.c arm_max_q7.c arm_kullback_leibler_f32.c arm_max_no_idx_f16.c arm_min_f64.c arm_var_f32.c arm_entropy_f32.c arm_power_q31.c arm_absmax_q15.c arm_rms_q15.c arm_max_f32.c arm_absmax_q7.c arm_var_q15.c arm_max_f16.c arm_rms_q31.c arm_absmax_f32.c arm_mean_f32.c arm_logsumexp_f16.c arm_absmin_f16.c arm_max_no_idx_q31.c arm_absmin_f32.c arm_std_f64.c arm_std_f32.c arm_power_f64.c arm_absmin_no_idx_f64.c arm_entropy_f64.c arm_mean_f64.c arm_min_no_idx_f32.c arm_absmin_no_idx_f32.c arm_power_f16.c arm_entropy_f16.c arm_min_q7.c arm_var_q31.c arm_absmax_f16.c arm_min_no_idx_q7.c arm_absmin_f64.c arm_mean_q31.c arm_min_q15.c arm_absmin_q31.c arm_min_f32.c arm_power_q7.c arm_max_q15.c arm_max_no_idx_q15.c arm_std_q31.c arm_accumulate_f64.c arm_mean_f16.c arm_rms_f16.c arm_logsumexp_f32.c arm_mse_f32.c arm_std_q15.c arm_accumulate_f16.c arm_absmin_no_idx_q15.c arm_min_q31.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmin_q15.c arm_absmax_f64.c arm_max_q31.c arm_logsumexp_dot_prod_f32.c arm_mse_q15.c arm_min_no_idx_q31.c arm_absmin_no_idx_q7.c arm_kullback_leibler_f16.c arm_min_no_idx_f64.c arm_min_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_var_f64.c arm_mse_f64.c arm_min_no_idx_f16.c arm_std_f16.c arm_absmin_no_idx_f16.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/BasicMathFunctions/: arm_offset_f32.c arm_negate_q31.c arm_add_q31.c arm_abs_q31.c arm_negate_f64.c arm_not_u32.c arm_clip_f16.c arm_mult_q7.c arm_abs_f64.c arm_shift_q31.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_xor_u8.c arm_scale_f32.c arm_offset_q15.c arm_or_u32.c arm_or_u16.c arm_negate_f16.c arm_abs_f32.c arm_abs_q7.c arm_negate_q15.c arm_offset_f16.c arm_negate_f32.c arm_xor_u32.c arm_offset_q31.c arm_sub_f32.c arm_add_f32.c arm_offset_q7.c arm_and_u16.c arm_mult_f64.c arm_sub_f64.c arm_add_f64.c arm_add_q15.c arm_dot_prod_q31.c arm_clip_q15.c arm_clip_q7.c arm_sub_q7.c arm_mult_f16.c arm_dot_prod_f16.c arm_or_u8.c arm_xor_u16.c arm_clip_f32.c arm_sub_q15.c arm_abs_f16.c arm_offset_f64.c arm_mult_q31.c arm_dot_prod_f32.c arm_scale_f64.c arm_scale_q31.c arm_add_q7.c arm_scale_f16.c arm_add_f16.c arm_not_u16.c arm_scale_q7.c arm_dot_prod_f64.c arm_sub_f16.c arm_not_u8.c arm_scale_q15.c arm_and_u8.c arm_mult_f32.c arm_shift_q7.c arm_shift_q15.c arm_negate_q7.c arm_sub_q31.c arm_and_u32.c arm_clip_q31.c arm_mult_q15.c arm_abs_q15.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/CommonTables/: arm_common_tables_f16.c arm_mve_tables_f16.c arm_const_structs_f16.c arm_const_structs.c arm_mve_tables.c arm_common_tables.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/FastMathFunctions/: arm_vexp_f64.c arm_atan2_f32.c arm_vlog_q31.c arm_atan2_q15.c arm_vlog_q15.c arm_atan2_f16.c arm_vinverse_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_sqrt_q31.c arm_cos_q15.c arm_sqrt_q15.c arm_vlog_f16.c arm_sin_q15.c arm_sin_q31.c arm_divide_q15.c arm_cos_f32.c arm_vexp_f32.c arm_cos_q31.c arm_vexp_f16.c arm_sin_f32.c arm_divide_q31.c arm_atan2_q31.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/MatrixFunctions/: arm_mat_vec_mult_q31.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_f16.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-dsp/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_dot_prod_f32.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_q31.c arm_cmplx_mult_real_q15.c arm_cmplx_mag_q15.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_conj_f32.c
  group mlevk_cmsis_nn
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/SoftmaxFunctions/: arm_softmax_s8_s16.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_s16.c arm_nn_softmax_common_s8.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/ConvolutionFunctions/: arm_depthwise_conv_wrapper_s16.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_s4_s16.c arm_convolve_even_s4.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s8.c arm_convolve_get_buffer_sizes_s8.c arm_convolve_1x1_s8.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_convolve_1_x_n_s4.c arm_depthwise_conv_s4_opt.c arm_convolve_s16.c arm_depthwise_conv_wrapper_s4.c arm_convolve_wrapper_s8.c arm_convolve_s8.c arm_convolve_s4.c arm_nn_mat_mult_kernel_s16.c arm_convolve_1x1_s8_fast.c arm_nn_mat_mult_kernel_s8_s16.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_transpose_conv_s8.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_nn_mat_mult_kernel_row_offset_s8_s16.c arm_depthwise_conv_s16.c arm_convolve_1x1_s4.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_get_buffer_sizes_s4.c arm_convolve_1x1_s4_fast.c arm_depthwise_conv_3x3_s8.c arm_convolve_1_x_n_s8.c arm_nn_mat_mult_s8.c arm_convolve_wrapper_s16.c arm_depthwise_conv_wrapper_s8.c arm_convolve_wrapper_s4.c arm_depthwise_conv_fast_s16.c arm_transpose_conv_get_buffer_sizes_s8.c arm_depthwise_conv_s4.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/NNSupportFunctions/: arm_nn_mat_mult_nt_interleaved_t_even_s4.c arm_nn_vec_mat_mult_t_s16_s16.c arm_nn_lstm_calculate_gate_s8_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mult_nt_t_s4.c arm_nn_lstm_step_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_s8_to_s16_unordered_with_offset.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nn_lstm_calculate_gate_s16.c arm_nn_mat_mul_core_1x_s4.c arm_nn_vec_mat_mult_t_s4.c arm_nn_mat_mult_nt_t_s16.c arm_nntables.c arm_q7_to_q15_with_offset.c arm_nn_vec_mat_mult_t_per_ch_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mul_result_acc_s16.c arm_nn_mat_mul_core_4x_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_lstm_step_s16.c arm_nn_depthwise_conv_nt_t_s4.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mul_result_acc_s8_s16.c arm_nn_depthwise_conv_nt_t_padded_s8.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/BasicMathFunctions/: arm_elementwise_mul_s16.c arm_elementwise_mul_acc_s16.c arm_elementwise_mul_s16_s8.c arm_elementwise_mul_s16_batch_offset.c arm_elementwise_add_s8.c arm_elementwise_mul_s8.c arm_elementwise_add_s16.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/PoolingFunctions/: arm_avgpool_get_buffer_sizes_s8.c arm_max_pool_s8.c arm_avgpool_s16.c arm_max_pool_s16.c arm_avgpool_s8.c arm_avgpool_get_buffer_sizes_s16.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c arm_svdf_get_buffer_sizes_s8.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/FullyConnectedFunctions/: arm_vector_sum_s8_s64.c arm_fully_connected_wrapper_s8.c arm_fully_connected_get_buffer_sizes_s16.c arm_batch_matmul_s8.c arm_fully_connected_s4.c arm_fully_connected_per_channel_s8.c arm_vector_sum_s8.c arm_fully_connected_get_buffer_sizes_s8.c arm_batch_matmul_s16.c arm_fully_connected_s16.c arm_fully_connected_s8.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/LSTMFunctions/: arm_lstm_unidirectional_s8.c arm_lstm_unidirectional_s16.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/ActivationFunctions/: arm_nn_activation_s16.c arm_relu_q15.c arm_relu_q7.c arm_relu6_s8.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/ConcatenationFunctions/: arm_concatenation_s8_y.c arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_z.c
    packages/ml-embedded-evaluation-kit/dependencies/cmsis-nn/Source/ReshapeFunctions/: arm_reshape_s8.c
  group mlevk_core
    packages/ml-embedded-evaluation-kit/source/application/api/common/source/: ImageUtils.cc TensorFlowLiteMicro.cc Classifier.cc Model.cc Mfcc.cc
    packages/ml-embedded-evaluation-kit/source/hal/source/components/poster/source/: poster_helper.c mqtt_pub.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/memheap_helper/source/: memheap_helper.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/lcd/source/rtthread/: lcd_helper.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/npu/: ethosu_profiler.c ethosu_npu_init.c ethosu_impl_rtt.c
    packages/ml-embedded-evaluation-kit/source/hal/source/platform/rtthread/source/: timer_native.c platform_drivers.c
    packages/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
    packages/ml-embedded-evaluation-kit/source/hal/source/: hal_pmu.c hal.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/stdout/source/: user_input.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/audio/source/: audio_helper.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/ext_file/source/: ext_file.c
    packages/ml-embedded-evaluation-kit/source/hal/source/components/camera/source/: camera_img.c
    packages/ml-embedded-evaluation-kit/source/application/main/: UseCaseCommonUtils.cc Main.cc
    packages/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    packages/ml-embedded-evaluation-kit/source/hal/source/components/uvc/source/: uvc_img.c descriptors.c
  group mlevk_npu_drv
    packages/ml-embedded-evaluation-kit/dependencies/core-driver/src/: ethosu_driver.c ethosu_device_u55_u65.c ethosu_pmu.c
  group mlevk_tflm
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/signal/micro/kernels/: window.cc fft_auto_scale_kernel.cc filter_bank_square_root.cc energy.cc fft_auto_scale_common.cc filter_bank_log.cc rfft.cc framer.cc irfft.cc filter_bank_square_root_common.cc stacker.cc overlap_add.cc filter_bank.cc pcan.cc delay.cc filter_bank_spectral_subtraction.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/kernels/: fill.cc batch_to_space_nd.cc space_to_batch_nd.cc unpack.cc read_variable.cc expand_dims.cc maximum_minimum.cc reshape.cc shape.cc log_softmax.cc quantize.cc elementwise.cc softmax_common.cc resize_nearest_neighbor.cc div.cc transpose.cc mul_common.cc kernel_util.cc logical.cc comparisons.cc slice.cc lstm_eval_common.cc exp.cc split_v.cc leaky_relu.cc split.cc if.cc ceil.cc kernel_runner.cc neg.cc hard_swish.cc activations_common.cc assign_variable.cc pack.cc zeros_like.cc add_n.cc micro_tensor_utils.cc sub_common.cc hard_swish_common.cc elu.cc l2norm.cc logical_common.cc gather.cc conv_common.cc leaky_relu_common.cc cast.cc concatenation.cc reduce_common.cc sub.cc circular_buffer.cc resize_bilinear.cc strided_slice_common.cc activations.cc prelu.cc l2_pool_2d.cc add_common.cc reduce.cc call_once.cc fully_connected_common.cc prelu_common.cc cumsum.cc svdf_common.cc depth_to_space.cc floor_div.cc embedding_lookup.cc dequantize.cc squeeze.cc depthwise_conv_common.cc broadcast_args.cc floor_mod.cc logistic_common.cc quantize_common.cc while.cc tanh.cc broadcast_to.cc var_handle.cc floor.cc logistic.cc round.cc detection_postprocess.cc squared_difference.cc select.cc reshape_common.cc mirror_pad.cc gather_nd.cc pooling_common.cc dequantize_common.cc strided_slice.cc lstm_eval.cc space_to_depth.cc arg_min_max.cc pad.cc batch_matmul.cc circular_buffer_common.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/: flatbuffer_utils.cc micro_allocation_info.cc micro_op_resolver.cc micro_log.cc micro_context.cc fake_micro_context.cc recording_micro_allocator.cc test_helpers.cc system_setup.cc micro_interpreter_context.cc mock_micro_graph.cc memory_helpers.cc micro_interpreter.cc micro_profiler.cc test_helper_custom_ops.cc micro_utils.cc micro_resource_variable.cc micro_allocator.cc micro_interpreter_graph.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/kernels/ethos_u/: ethosu.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/: array.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/signal/src/: irfft_int32.cc msb_32.cc fft_auto_scale.cc rfft_int16.cc filter_bank_log.cc irfft_int16.cc rfft_float.cc square_root_64.cc filter_bank_spectral_subtraction.cc msb_64.cc pcan_argc_fixed.cc filter_bank.cc energy.cc rfft_int32.cc window.cc circular_buffer.cc filter_bank_square_root.cc max_abs.cc overlap_add.cc square_root_32.cc log.cc irfft_float.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/kernels/cmsis_nn/: mul.cc add.cc transpose_conv.cc conv.cc softmax.cc svdf.cc depthwise_conv.cc pooling.cc fully_connected.cc unidirectional_sequence_lstm.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/memory_planner/: non_persistent_buffer_planner_shim.cc greedy_memory_planner.cc linear_memory_planner.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/kernels/internal/: common.cc tensor_utils.cc quantization_util.cc runtime_shape.cc portable_tensor_utils.cc tensor_ctypes.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/signal/src/kiss_fft_wrappers/: kiss_fft_int16.cc kiss_fft_int32.cc kiss_fft_float.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/kernels/internal/reference/: comparisons.cc portable_tensor_utils.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/arena_allocator/: persistent_arena_buffer_allocator.cc recording_single_arena_buffer_allocator.cc non_persistent_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/cortex_m_generic/: micro_time.cc debug_log.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/core/c/: common.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/core/api/: flatbuffer_conversions.cc tensor_utils.cc error_reporter.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cc micro_error_reporter.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/kernels/: kernel_util.cc
    packages/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/compiler/mlir/lite/schema/: schema_utils.cc
  group mlevk_usecase
    packages/ml-embedded-evaluation-kit/source/use_case/object_detection/src/: MainLoop.cc UseCaseHandler.cc
    packages/ml-embedded-evaluation-kit/ethos-u55-256-gnu_generated/object_detection/src/: couple.cc InputFiles.cc glasses.cc pitch_and_roll.cc yolo-fastest_192_face_v4_vela_H256.tflite.cc man_and_baby.cc
    packages/ml-embedded-evaluation-kit/source/application/api/use_case/object_detection/src/: DetectorPostProcessing.cc DetectorPreProcessing.cc YoloFastestModel.cc
  group mpu6xxx
    packages/mpu6xxx-latest/src/: sensor_inven_mpu6xxx.c mpu6xxx.c
  group NetUtils
    packages/netutils-latest/ntp/: ntp.c
  group nu_pkgs_ccap
    libraries/nu_packages/CCAP_Sensors/: sensor_hm1055.c sensor_xc7082_ov2718.c sensor_adv728x.c sensor_ov5640.c ccap_sensor.c
  group nu_pkgs_lt7381
    libraries/nu_packages/LT7381/: lcd_lt7381.c lt7381_ebi.c
  group nu_pkgs_nau8822
    libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau8822.c
  group nu_pkgs_tpc
    libraries/nu_packages/TPC/: tpc_worker.c ft5446.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group RyanMqtt
    packages/ml-embedded-evaluation-kit/dependencies/RyanMqtt/mqttclient/: RyanMqttUtile.c RyanMqttClient.c RyanMqttThread.c
    packages/ml-embedded-evaluation-kit/dependencies/RyanMqtt/pahoMqtt/: MQTTConnectClient.c MQTTPacket.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTUnsubscribeServer.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTSerializePublish.c MQTTSubscribeServer.c
    packages/ml-embedded-evaluation-kit/dependencies/RyanMqtt/platform/rtthread/: platformSystem.c platformTimer.c platformNetwork.c
    packages/ml-embedded-evaluation-kit/dependencies/RyanMqtt/common/: RyanList.c
    packages/ml-embedded-evaluation-kit/dependencies/RyanMqtt/example/: RyanMqttTest.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
